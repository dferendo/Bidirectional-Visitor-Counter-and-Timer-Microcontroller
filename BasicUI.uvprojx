# Keil uVision project BasicUI.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: BasicUI
  c flags: Optim=1 wLevel=2
  c include: .\drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group drivers
    ./drivers/: Platform.h Timer.c Timer.h RealClockTimer.h RealClockTimer.c Gpio.c Gpio.h EEPROM.h EEPROM.c
  group src
    ./src/: Buzzer.c Buzzer.h LED.c LED.h CounterMode.c CounterMode.h InterviewMode.h InterviewMode.c IRModule.c IRModule.h RTCTimerUtil.h RTCTimerUtil.c Delay.h Delay.c Main.c LCD.h LCD.c ISR.h ISR.c EEPROMReadMode.h EEPROMReadMode.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
